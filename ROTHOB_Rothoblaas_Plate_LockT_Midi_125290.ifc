Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 430257ba-d53c-40e9-8699-f8338b236b76, NumberOfSaves: 8], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: ROTHOB_Rothoblaas_Plate_LockT_Midi_125290.ifc
Time: 2026-03-24T15:37:40
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:1/4" Head, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 1/4" Head; Type: 1/4" Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 1/4" Head
Other(Type) - Category: Levels; Family Name: Level

# IfcMember: Structural Connections : ROTHOB_Rothoblaas_Plate_LockT_Midi_125290 : LOCKT125290_125x290x22mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_Aluminium
Type - Visibility - HasHole_LOCKT100215: no; HasHole_LOCKT100240: no; HasHole_LOCKT100265: no; HasHole_LOCKT100290: no; HasHole_LOCKT125240: no; HasHole_LOCKT125265: no; HasHole_LOCKT125290: yes; HasHole_LOCKT50135: no; HasHole_LOCKT50175: no; HasHole_LOCKT75175: no; HasHole_LOCKT75215: no; HasHole_LOCKT75240: no; HasHole_LOCKT75265: no; HasHole_LOCKT75290: no
Type - General - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Plate_LockT_Midi; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/concealed-connections/lock-t-midi; Revision: 002; UniClass2015Code: Pr_20_76_51_07; UniClass2015Title: Aluminium structural sections; UniClass2015Version: Products v1.41; Version: 002
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 125290
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_Aluminium
Type - Dimensions - Depth_P: 22 mm; Height_H: 290 mm; HoleQuantity_nscrews_Ø7: 90; Width_B: 125 mm
Type - Identity Data - Description: Concealed timber-to-timber connector; Manufacturer: info@rothoblaas.com; OmniClass Number: 23.13.23.11.19.13; Type Name: LOCKT125290_125x290x22mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: Fixed; CECode: ETA-19/0831; CETitle: Rotho Blaas LOCK Connectors; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description_2: Concealed timber-to-timber connector; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_LockT_Midi_125290; Features: Bracket for timber-to-timber, timber-to-concrete, timber-to-steel joints; Finish: n/a; Grade: n/a; GTIN: 8033874230237; Manufacturer_2: info@rothoblaas.com; Material: Aluminium; MinWeight: 1.31 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: LOCKT125290; ModelReference: n/a; Name: Plate; NominalDepth: 22 mm; NominalHeight: 290 mm; NominalLength: n/a; NominalWidth: 125 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 125x290x22 mm; Size_Imperial: 4 15/16x11 7/16x0.87 in; SustainabilityPerformance: BVB Accepted / Sundahus A; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate
Pset_MemberCommon - Reference: LOCKT125290_125x290x22mm
Pset_QuantityTakeOff - Reference: LOCKT125290_125x290x22mm
BaseQuantities - Length: 125 mm; CrossSectionArea: 0.00185044 m2; OuterSurfaceArea: 0.078377 m2; GrossSurfaceArea: 0.0820778 m2; GrossVolume: 0.000231304 m3; NetVolume: 0.000218732 m3; NetSurfaceArea: 0.0844193 m2
Constraints - Elevation from Level: -6.57191 mm; Host: Reference Plane; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <0' - 1">
Dimensions - Volume: 0.000218732 m3
Other - Family: ROTHOB_Rothoblaas_Plate_LockT_Midi_125290; Family and Type: ROTHOB_Rothoblaas_Plate_LockT_Midi_125290: LOCKT125290_125x290x22mm; Type: LOCKT125290_125x290x22mm; Type Id: 621883

# IfcOpeningElement: Opening (45)
In: 0_Rothoblaas
BaseQuantities - Depth: 125 mm; Area: 0.00185044 m2
Pset_OpeningElementCommon - Reference: LOCKT125290_125x290x22mm; sets with these values: 2
Name (Structural Connections : ROTHOB_Rothoblaas_Plate_LockT_Midi_125290 : LOCKT125290_125x290x22mm:...)
1
2
3
4
5
6
7
8
9
10
11
12
13
14
15
16
17
18
19
20
21
22
23
24
25
26
27
28
29
30
31
32
33
34
35
36
37
38
39
40
41
42
43
44
45
